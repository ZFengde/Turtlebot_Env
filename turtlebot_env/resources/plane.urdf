Commit message: update

File: turtlebot_env/resources/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=4.5 4.5 0.01; visual box size=4.5 4.5 0.01
